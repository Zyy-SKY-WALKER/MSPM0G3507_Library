# Keil uVision project SeekFree_MSPM0G3507_Device_Library.uvprojx, settings and files
target SeekFree_MSPM0G3507_Device_Library (6240000::V6.24::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20200000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: SeekFree_MSPM0G3507_Device_Library +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3507__
  c include: ..\..\libraries\sdk\third_party\CMSIS\Core\Include;..\..\libraries\sdk;..\..\libraries\sdk\ti_config;..\..\libraries\zf_common;..\..\libraries\zf_components;..\..\libraries\zf_device;..\..\libraries\zf_driver;..\user\inc;..\code;..\my_lib;..\test
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20200000 size 0x8000
  scatter file: .\mspm0g3507.sct
  group code
    ../code/: motor.c motor.h 新建文本文档.txt speed_pid.c speed_pid.h imu_uart.c imu_uart.h
  group user
    ../user/src/: main.c isr.c
    ../user/inc/: isr.h
  group zf_common
    ../../libraries/zf_common/: zf_common_clock.c zf_common_clock.h zf_common_debug.c zf_common_debug.h zf_common_fifo.c zf_common_fifo.h zf_common_font.c zf_common_font.h zf_common_function.c zf_common_function.h zf_common_headfile.h zf_common_interrupt.c zf_common_interrupt.h zf_common_typedef.h
  group zf_components
    ../../libraries/zf_components/: seekfree_assistant.c seekfree_assistant.h seekfree_assistant_interface.c seekfree_assistant_interface.h
  group zf_driver
    ../../libraries/zf_driver/: zf_driver_adc.c zf_driver_adc.h zf_driver_delay.c zf_driver_delay.h zf_driver_exti.c zf_driver_exti.h zf_driver_gpio.c zf_driver_gpio.h zf_driver_pit.c zf_driver_pit.h zf_driver_pwm.c zf_driver_pwm.h zf_driver_soft_iic.c zf_driver_soft_iic.h zf_driver_spi.c zf_driver_spi.h zf_driver_timer.c zf_driver_timer.h zf_driver_uart.c zf_driver_uart.h zf_driver_flash.c zf_driver_flash.h zf_driver_encoder.c zf_driver_encoder.h
  group zf_device
    ../../libraries/zf_device/: zf_device_absolute_encoder.c zf_device_absolute_encoder.h zf_device_config.h zf_device_config.lib zf_device_dl1a.c zf_device_dl1a.h zf_device_dl1b.c zf_device_dl1b.h zf_device_imu660ra.c zf_device_imu660ra.h zf_device_imu660rb.c zf_device_imu660rb.h zf_device_imu660rc.c zf_device_imu660rc.h zf_device_imu963ra.c zf_device_imu963ra.h zf_device_ips114.c zf_device_ips114.h zf_device_ips200.c zf_device_ips200.h zf_device_ips200pro.c zf_device_ips200pro.h zf_device_tft180.c zf_device_tft180.h zf_device_tsl1401.c zf_device_tsl1401.h zf_device_type.c zf_device_type.h zf_device_wifi_spi.c zf_device_wifi_spi.h zf_device_wifi_uart.c zf_device_wifi_uart.h zf_device_wireless_uart.c zf_device_wireless_uart.h zf_device_key.c zf_device_key.h zf_device_oled.c zf_device_oled.h zf_device_gs08ra.c zf_device_gs08ra.h
  group ti_config
    ../../libraries/sdk/ti_config/: startup_mspm0g350x_uvision.s ti_msp_dl_config.c ti_msp_dl_config.h
  group Driverlib
    ../../libraries/sdk/ti/driverlib/: dl_adc12.c dl_aes.c dl_aesadv.c dl_common.c dl_comp.c dl_crc.c dl_crcp.c dl_dac12.c dl_dma.c dl_flashctl.c dl_gpamp.c dl_gpio.c dl_i2c.c dl_iwdt.c dl_keystorectl.c dl_lcd.c dl_lfss.c dl_mathacl.c dl_mcan.c dl_opa.c dl_rtc.c dl_rtc_a.c dl_rtc_b.c dl_rtc_common.c dl_scratchpad.c dl_spi.c dl_tamperio.c dl_timer.c dl_timera.c dl_timerg.c dl_trng.c dl_uart.c dl_vref.c dl_wwdt.c
    ../../libraries/sdk/ti/driverlib/m0p/sysctl/: dl_sysctl_mspm0g1x0x_g3x0x.c
  group doc
    ../../libraries/doc/: version.txt
  group my_lib
    ../my_lib/: my_lib_ili9341.c my_lib_ili9341.h ml_oled.c ml_oled.h ml_oled_font.h my_lib_encoder.c my_lib_encoder.h
  group test
    ../test/: test_config.h test_ili9341.c test_ili9341.h test_motor.c test_motor.h test_encoder.c test_encoder.h test_speed_pid.c test_speed_pid.h test_imu_uart.c test_imu_uart.h
